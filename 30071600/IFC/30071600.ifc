Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Users\Jonas\Documents\Cadfocus\Ostnor\20140117_CAD-objekt_serie-Rogen\ARBETSMAPP\30071600\AutoCAD Architecture\30071600.ifc
Time: 2014-01-30T15:51:02
Author: - -
Organization: FM Mattsson
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 30071600
LongName: 30071600
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Medium Detail; ACA_DISPLAY_SET_ON_EXPORT: Model

# IfcBuilding, 30071600
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 30071600, BUILDINGELEMENTPROXY(1)
In: 30071600
Description: FM Mattsson Rogen Sink Mixer
